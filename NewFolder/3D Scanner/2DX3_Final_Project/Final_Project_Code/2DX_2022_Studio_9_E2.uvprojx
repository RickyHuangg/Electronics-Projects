# Keil uVision project 2DX_2022_Studio_9_E2.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2dx4_dsA0-1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: onboardLEDs.c PLL.c SysTick.c uart.c 2DX_2022_Studio_9_E2.c vl53l1_platform_2dx4.c vl53l1_platform_2dx4.h vl53l1_types.h VL53L1X_api.c
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.3
